File: Circuitos/Condensador en AC [Kicad]/Condensador AC.kicad_sch (KiCad schematic)
At the start: 3 parts

Commit message: .
Parts:
- C1: value 100nF -> 10uF
